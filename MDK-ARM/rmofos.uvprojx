# Keil uVision project rmofos.uvprojx, settings and files
target rmofos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rmofos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\User\user_task\inc;..\User\drivers\modules\inc;..\User\drivers\counters\inc;..\User\drivers\data_structure\inc;..\User\bsp\inc;..\User\app\inc;..\User\drivers\data_structure\inc
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group user/bsp
    ../User/bsp/src/: baseclass.c bsp_usart.c bsp_can.c
    ../User/bsp/inc/: bsp_can.h
  group user/drivers
    ../User/drivers/modules/src/: motor.c DJI_dbus.c leds_tip.c wholepositioning.c niming.c
    ../User/drivers/modules/inc/: DJI_dbus.h leds_tip.h wholepositioning.h
    ../User/drivers/counters/src/: counters.c motion_model.c
    ../User/drivers/counters/inc/: counters.h motion_model.h
    ../User/drivers/data_structure/src/: DataStructure.c
    ../User/drivers/data_structure/inc/: DataStructure.h
  group user/app
    ../User/app/src/: chassis.c gimbal.c parse.c rc_chassis.c send_message.c auto_chassis.c
    ../User/app/inc/: chassis.h gimbal.h parse.h rc_chassis.h send_message.h auto_chassis.h
  group user_task
    ../User/user_task/src/: sys_task.c user.c
    ../User/user_task/inc/: sys_task.h user.h
software components: CMSIS:CORE 4.3.0
